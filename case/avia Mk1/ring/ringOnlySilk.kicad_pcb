File: case/avia Mk1/ring/ringOnlySilk.kicad_pcb (KiCad board)
At the start: 2 copper layers, 44 x 43.6 mm, 1 part

Commit message: small corrections
Other:
- board text added: "MPH"
